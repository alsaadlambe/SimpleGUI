# Keil uVision project SimpleGUI_Demo.uvprojx, settings and files
target SimpleGUI_Demo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SimpleGUI_Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\GUI\inc;..\..\..\..\HMI\inc;..\..\..\..\DemoProc\inc;..\..\Core\inc;..\..\Demo\inc;..\..\Device\inc;..\..\SPL\inc;..\..\System\inc;..\..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../../Core/src/: core_cm3.c
  group Startup
    ../../Startup/src/: startup_stm32f10x_hd_mdk.s
  group SPL
    ../../SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/src/: main.c system_stm32f10x.c usart_io.c
  group Demo
    ../../Demo/src/: DemoActions.c
    ../../../../DemoProc/src/: DemoProc.c List.c RealtimeGraph.c RTCNotice.c ScrollingText.c TextNotice.c VariableBox.c
  group Device
    ../../Device/src/: ASCII_Font8Pix.c OLED.c SSD1306_SPI.c
  group GUI
    ../../../../GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_FlashData.c SGUI_Frame.c SGUI_Graph.c SGUI_List.c SGUI_Notice.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c SGUI_VariableBox.c
  group HMI
    ../../../../HMI/src/: HMI_Engine.c
  group System
    ../../System/src/: Delay.c ExternalInterrupt.c GPIO.c Initialize.c MMU.c RTC.c SDIO.c Systick.c Timer.c Usart.c
